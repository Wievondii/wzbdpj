# Keil uVision project parking_system.uvprojx, settings and files
target parking_system (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(8000000) ELITTLE
  output: parking_system +hex
  c flags: Optim=1 OneElfS=1
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: USER;CORE;SYSTEM\sys;SYSTEM\delay;SYSTEM\usart;HARDWARE\GPIO;HARDWARE\KEY;HARDWARE\MOTOR_DUOJI;HARDWARE\OLED;HARDWARE\ALARM;STM32F10x_FWLib\inc
